# Keil uVision project stm32-pcf8591.uvproj, settings and files
target HC6800-EM3 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-pcf8591 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group use
    ./: main.c I2C.C
  group stm32f10xxLib
    ./: STM32F10xR.LIB
  group RVMDK
    ./: STM32F10x.s
